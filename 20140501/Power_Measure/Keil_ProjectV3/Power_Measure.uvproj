# Keil uVision project Power_Measure.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Power_Measure +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CPU_Register;..\Hard_Module;..\System_Function
  group Source Group 1
    ../CPU_Register/: C_STC12C5404ADMdu.c
    ../Hard_Module/: C_CS5460.c C_STCE2PROM.c
    ../System_Function/: C_Main.c
