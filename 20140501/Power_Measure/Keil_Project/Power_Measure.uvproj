# Keil uVision project Power_Measure.uvproj, settings and files
target Power_Measure (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Power_Measure +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hard_Module;..\System_Function;..\CPU_Register
  group System_Function
    ../System_Function/: C_Main.c
  group Hard_Module
    ../Hard_Module/: C_CS5460.c C_STCE2PROM.c
  group CPU_Register
    ../CPU_Register/: C_STC12C5404ADMdu.c
